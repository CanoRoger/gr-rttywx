options:
  parameters:
    author: Roger Cano
    generate_options: no_gui
    id: rttywx_decoder_example
    output_language: python
    title: HF RTTY weather decoder example
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '0.3'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0_0_1_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 40.0/(48000/audio_rate)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: pulse
    samp_rate: audio_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: pulse
    samp_rate: audio_rate
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {state: disabled}
- name: blocks_multiply_xx_2_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_vco_c_0_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: audio_rate
    sensitivity: '-2*3.14159*290/1.5'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/cano/Desktop/seaTTY/rttywx/examples/rtty.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/cano/Desktop/seaTTY/rttywx/examples/rtty.wav
    repeat: 'True'
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_3_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '2000'
    comment: |-
      AFC branch. Although it works well with 
      a real SDR, this is not optimized for this
      example. Use the disabled blocks in below
      instead for optimum results.
    decim: '1'
    samp_rate: audio_rate
    taps: firdes.low_pass(1.0,audio_rate,1,2000)
    type: ccf
  states: {}
- name: gr_moving_average_xx_0_1_0
  id: blocks_moving_average_xx
  parameters:
    length: int(1*audio_rate)
    max_iter: int(audio_rate)
    scale: 1.0/(1*audio_rate)
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: '8000'
    type: fff
  states: {}
- name: rttywx_rttywx_decode_0
  id: rttywx_rttywx_decode
  parameters:
    filename: ''
    reverse: 'True'
    samp_rate: '8000'
    type: short
  states: {}
- name: rttywx_rttywx_decode_0_0
  id: rttywx_rttywx_decode
  parameters:
    filename: ''
    reverse: 'True'
    samp_rate: '8000'
    type: short
  states: {state: disabled}

connections:
- [analog_agc3_xx_0, '0', blocks_multiply_xx_2_0, '0']
- [analog_agc3_xx_0, '0', freq_xlating_fir_filter_xxx_0_3_0, '0']
- [analog_quadrature_demod_cf_0_0_1_0, '0', gr_moving_average_xx_0_1_0, '0']
- [audio_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_real_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_complex_0, '0', analog_agc3_xx_0, '0']
- [blocks_float_to_short_0, '0', rttywx_rttywx_decode_0, '0']
- [blocks_float_to_short_0_0, '0', rttywx_rttywx_decode_0_0, '0']
- [blocks_multiply_xx_2_0, '0', blocks_complex_to_real_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_vco_c_0_0, '0', blocks_multiply_xx_2_0, '1']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_0, '0', blocks_float_to_short_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_3_0, '0', analog_quadrature_demod_cf_0_0_1_0, '0']
- [gr_moving_average_xx_0_1_0, '0', blocks_vco_c_0_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_short_0, '0']

metadata:
  file_format: 1
